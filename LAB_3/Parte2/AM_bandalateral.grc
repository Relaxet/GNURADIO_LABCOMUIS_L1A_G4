options:
  parameters:
    author: Miguel Garcia
    generate_options: qt_gui
    id: AM_bandalateral
    output_language: python
    title: modulacion en banda lateral unica
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: amplitud portadora
    start: '0'
    step: '.1'
    stop: '1'
    value: '.125'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud mensaje
    start: '0'
    step: '.1'
    stop: '4'
    value: '1'
  states: {}
- name: B
  id: variable_qtgui_range
  parameters:
    label: cambio de banda
    start: '-1'
    step: '2'
    stop: '1'
    value: '1'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: ganancia
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: frecuencia portadora
    start: '50000000'
    step: '1000000'
    stop: '2200000000'
    value: '50000000'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: frecuencia mensaje
    start: '200'
    step: '100'
    stop: '21000'
    value: '1000'
  states: {}
- name: k
  id: variable_qtgui_range
  parameters:
    label: A1
    start: '0'
    step: '1'
    stop: '1'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 12500000/8
  states: {}
- name: Calculo_potencia_0
  id: Calculo_potencia
  parameters:
    l_vect: '1024'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: ec_SSB_0
  id: ec_SSB
  parameters:
    Ac: Ac
    B: B
    K: k
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', Calculo_potencia_0, '0']
- [analog_sig_source_x_0, '0', ec_SSB_0, '0']
- [ec_SSB_0, '0', qtgui_freq_sink_x_0, '0']
- [ec_SSB_0, '0', qtgui_time_sink_x_0, '0']
- [ec_SSB_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
