options:
  parameters:
    author: Miguel Garcia
    copyright: UIS
    generate_options: qt_gui
    id: PruebaPAM
    output_language: python
    title: LAB_5_5
  states: {}

blocks:
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud de mensaje
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: D
  id: variable_qtgui_range
  parameters:
    label: Ancho de pulso
    start: '0'
    step: '1'
    stop: '50'
    value: '10'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: frecuencia del mensaje
    start: '0'
    step: '10'
    stop: '10000'
    value: '100'
  states: {}
- name: fs
  id: variable_qtgui_range
  parameters:
    label: Frecuencia Pulsos
    start: '0'
    step: '1'
    stop: '10000'
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: ModuladorPAM_0
  id: ModuladorPAM
  parameters:
    d: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 50e6
    gain0: '0'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [ModuladorPAM_0, '0', blocks_float_to_complex_0, '0']
- [ModuladorPAM_0, '0', qtgui_freq_sink_x_0, '0']
- [ModuladorPAM_0, '0', qtgui_time_sink_x_0, '0']
- [analog_sig_source_x_0, '0', ModuladorPAM_0, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_float_to_complex_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
